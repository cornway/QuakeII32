# Keil uVision project Project.uvprojx, settings and files
target application-ram (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ../Quake-2/game
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group main
    ./: startup.s
  group q2
    ../Quake-2/client/: cl_cin.c cl_ents.c cl_fx.c cl_input.c cl_inv.c cl_main.c cl_newfx.c cl_parse.c cl_pred.c cl_scrn.c cl_tent.c cl_view.c console.c keys.c menu.c qmenu.c snd_dma.c snd_mem.c snd_mix.c
    ../Quake-2/ctf/: g_ai.c g_chase.c g_cmds.c g_combat.c g_ctf.c g_func.c g_items.c g_main.c g_misc.c g_monster.c g_phys.c g_save.c g_spawn.c g_svcmds.c g_target.c g_trigger.c g_utils.c g_weapon.c m_move.c p_client.c p_hud.c p_menu.c p_trail.c p_view.c p_weapon.c q_shared.c
    ../Quake-2/game/: g_turret.c m_actor.c m_berserk.c m_boss2.c m_boss3.c m_boss31.c m_boss32.c m_brain.c m_chick.c m_flash.c m_flipper.c m_float.c m_flyer.c m_gladiator.c m_gunner.c m_hover.c m_infantry.c m_insane.c m_medic.c m_mutant.c m_parasite.c m_soldier.c m_supertank.c m_tank.c
    ../Quake-2/null/: cd_null.c in_null.c snddma_null.c swimp_null.c sys_null.c vid_null.c
    ../Quake-2/qcommon/: cmd.c cmodel.c common.c crc.c cvar.c files.c md4.c net_chan.c pmove.c
    ../Quake-2/ref_soft/: r_aclip.c r_alias.c r_bsp.c r_draw.c r_edge.c r_image.c r_light.c r_main.c r_misc.c r_model.c r_part.c r_poly.c r_polyse.c r_rast.c r_scan.c r_sprite.c r_surf.c
    ../Quake-2/server/: sv_ccmds.c sv_ents.c sv_game.c sv_init.c sv_main.c sv_null.c sv_send.c sv_user.c sv_world.c
software components: CMSIS:CORE 5.1.2
